# IAR project Project.ewp, settings and files
configuration STM32303E_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VE ST STM32F303VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xE; USE_STM32303E_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32303E_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Log; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32303E_EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f303xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/EWARM
    ./: startup_stm32f303xe.s
  group Application/User
    ../Src/: main.c stm32f3xx_it.c
  group Drivers/BSP/STM32303E_EVAL
    ../../../../../../Drivers/BSP/STM32303E_EVAL/: stm32303e_eval.c stm32303e_eval_sd.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_i2c.c stm32f3xx_hal_spi.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
